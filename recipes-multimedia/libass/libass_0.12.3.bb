require ${PN}.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "648ee785f966c69d4b5d50948e509d93"
SRC_URI[sha256sum] = "5aa6b02b00de7aa2d795e8afa77def47485fcc68a190f4326b6e4d40aee30560"

